
# Strip unnecessary features to make smaller SDK package
RDEPENDS_${PN} = ""

